Commit message: 向world中导入桌子、杯子

File: rm_gazebo/config/gazebo_65_description.urdf.xacro (robot description, xacro)
@@ -8,4 +8,5 @@
         <parent link="world"/>
         <child link="base_link"/>
+        <origin xyz="0 0 0.815" rpy="0 0 0"/>
     </joint>
     <!-- 对一些link进行gazebo的属性设置 -->
